/* LED output, generated by Bolt Bench — overwritten on export.

   The wire and nothing else. storm.h renders a finished frame into leds[];
   this applies brightness, white balance and the power cap, and sends it.

   The colour math stays FastLED's, because the bench transcribes it bit for
   bit. The driver is Adafruit NeoPixel. FastLED 3.10's ESP32 output lit the
   right number of pixels but every colour came out white, and NeoPixel on the
   same board and strand showed the colours correctly. */
#pragma once
#include <Adafruit_NeoPixel.h>
#include <FastLED.h>
#include "config.h"
#include "layout.h"

/* FastLED's power model, so the figures match its calculate_*_power_mW():
   milliwatts per channel at full drive, and per pixel at rest. */
#define STRIP_MW_RED    80
#define STRIP_MW_GREEN  55
#define STRIP_MW_BLUE   75
#define STRIP_MW_DARK    5
#define STRIP_VOLTS      5
#define STRIP_DARK_MW   ((uint32_t)NUM_LEDS * STRIP_MW_DARK)   // the whole strip, all off

static Adafruit_NeoPixel strip(NUM_LEDS, LED_PIN, LED_TYPE);

void stripBegin() {
  strip.begin();
  strip.show();                        // all off until the first frame
}

/* Brightness first, exactly as the bench applies it, then white balance. */
static inline CRGB stripColor(const CRGB &c, uint8_t bright, const CRGB &wb) {
  return CRGB(scale8(scale8(c.r, bright), wb.r),
              scale8(scale8(c.g, bright), wb.g),
              scale8(scale8(c.b, bright), wb.b));
}

/* What the lit pixels draw, in mW, on top of STRIP_DARK_MW. */
static uint32_t stripLit_mW(const CRGB *px, uint8_t bright, const CRGB &wb) {
  uint32_t r = 0, g = 0, b = 0;
  for (uint16_t i = 0; i < NUM_LEDS; i++) {
    CRGB c = stripColor(px[i], bright, wb);
    r += c.r; g += c.g; b += c.b;
  }
  return (r * STRIP_MW_RED + g * STRIP_MW_GREEN + b * STRIP_MW_BLUE) >> 8;
}

/* Sends the frame and returns what the strip draws, in mW. With LED_MAX_MA
   set, a frame that would draw more is dimmed as a whole to fit, the way
   FastLED's setMaxPowerInVoltsAndMilliamps() does. */
uint32_t stripShow(const CRGB *px, uint8_t bright) {
  const CRGB wb(LED_CORRECTION);
  uint32_t lit = stripLit_mW(px, bright, wb);

#if LED_MAX_MA
  const uint32_t budget = (uint32_t)LED_MAX_MA * STRIP_VOLTS;
  const uint32_t litBudget = budget > STRIP_DARK_MW ? budget - STRIP_DARK_MW : 0;
  if (lit > litBudget) {
    bright = (uint8_t)((uint32_t)bright * litBudget / lit);
    lit = stripLit_mW(px, bright, wb);
  }
#endif

  for (uint16_t i = 0; i < NUM_LEDS; i++) {
    CRGB c = stripColor(px[i], bright, wb);
    strip.setPixelColor(i, c.r, c.g, c.b);   // NeoPixel reorders for LED_TYPE
  }
  strip.show();
  return lit + STRIP_DARK_MW;
}
